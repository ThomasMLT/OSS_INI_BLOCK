v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 -760 -340 {}
P 4 5 -850 -520 -680 -520 -680 -350 -850 -350 -850 -520 {}
P 4 1 -520 -340 {}
P 4 5 -610 -520 -440 -520 -440 -350 -610 -350 -610 -520 {}
P 4 1 -280 -340 {}
P 4 5 -370 -520 -200 -520 -200 -350 -370 -350 -370 -520 {}
T {POWER SUPPLY} -850 -550 0 0 0.4 0.4 {}
T {ANALOG SIGNAL} -610 -550 0 0 0.4 0.4 {}
T {DIGITAL SIGNAL} -370 -550 0 0 0.4 0.4 {}
N -180 10 -180 80 {lab=vssa}
N -320 80 -180 80 {lab=vssa}
N 340 10 340 80 {lab=vssa}
N 500 10 500 80 {lab=vssa}
N 670 10 670 80 {lab=vssa}
N 830 80 1000 80 {lab=vssa}
N 1000 10 1000 80 {lab=vssa}
N -180 80 -10 80 {lab=vssa}
N -10 80 160 80 {lab=vssa}
N 160 80 340 80 {lab=vssa}
N 340 80 500 80 {lab=vssa}
N 500 80 670 80 {lab=vssa}
N 670 80 830 80 {lab=vssa}
N 1000 80 1120 80 {lab=vssa}
N 1120 -200 1120 -50 {lab=ref_VUN[0]}
N 1070 -200 1120 -200 {lab=ref_VUN[0]}
N 1000 -200 1000 -140 {lab=ref_VUN[0]}
N 940 -200 940 -50 {lab=ref_VUN[1]}
N 890 -200 940 -200 {lab=ref_VUN[1]}
N 830 -200 830 -140 {lab=ref_VUN[1]}
N 780 -200 780 -50 {lab=ref_VUN[2]}
N 730 -200 780 -200 {lab=ref_VUN[2]}
N 670 -200 670 -140 {lab=ref_VUN[2]}
N 610 -200 610 -50 {lab=ref_VUN[3]}
N 560 -200 610 -200 {lab=ref_VUN[3]}
N 500 -200 500 -140 {lab=ref_VUN[3]}
N 450 -200 450 -50 {lab=ref_VUN[4]}
N 400 -200 450 -200 {lab=ref_VUN[4]}
N 340 -200 340 -140 {lab=ref_VUN[4]}
N 270 -200 270 -50 {lab=ref_VUN[5]}
N 210 -200 270 -200 {lab=ref_VUN[5]}
N 160 -200 160 -140 {lab=ref_VUN[5]}
N 50 -200 100 -200 {lab=ref_VUN[6]}
N -10 -200 -10 -140 {lab=ref_VUN[6]}
N -80 -200 -80 -50 {lab=ref_VUN[7]}
N -130 -200 -80 -200 {lab=ref_VUN[7]}
N -180 -200 -180 -140 {lab=ref_VUN[7]}
N 70 -50 100 -50 {lab=ref_VUN[6]}
N 100 -200 100 -50 {lab=ref_VUN[6]}
N -100 -50 -80 -50 {lab=ref_VUN[7]}
N 240 -50 270 -50 {lab=ref_VUN[5]}
N 420 -50 450 -50 {lab=ref_VUN[4]}
N 580 -50 610 -50 {lab=ref_VUN[3]}
N 910 -50 940 -50 {lab=ref_VUN[1]}
N 1080 -50 1120 -50 {lab=ref_VUN[0]}
N -100 -90 1190 -90 {lab=en_VS}
N 750 -50 780 -50 {lab=ref_VUN[2]}
N 160 10 160 80 {lab=vssa}
N -10 10 -10 80 {lab=vssa}
N 830 10 830 80 {lab=vssa}
N -180 -200 -130 -200 {lab=ref_VUN[7]}
N -10 -200 50 -200 {lab=ref_VUN[6]}
N 160 -200 210 -200 {lab=ref_VUN[5]}
N 340 -200 400 -200 {lab=ref_VUN[4]}
N 500 -200 560 -200 {lab=ref_VUN[3]}
N 670 -200 730 -200 {lab=ref_VUN[2]}
N 830 -200 890 -200 {lab=ref_VUN[1]}
N 1000 -200 1070 -200 {lab=ref_VUN[0]}
N 1070 -320 1070 -200 {lab=ref_VUN[0]}
N 890 -320 890 -200 {lab=ref_VUN[1]}
N 730 -320 730 -200 {lab=ref_VUN[2]}
N 560 -320 560 -200 {lab=ref_VUN[3]}
N 400 -320 400 -200 {lab=ref_VUN[4]}
N 210 -320 210 -200 {lab=ref_VUN[5]}
N 50 -320 50 -200 {lab=ref_VUN[6]}
N -130 -320 -130 -200 {lab=ref_VUN[7]}
N -180 10 -150 10 {lab=vssa}
N -10 10 20 10 {lab=vssa}
N 160 10 190 10 {lab=vssa}
N 340 10 370 10 {lab=vssa}
N 500 10 530 10 {lab=vssa}
N 670 10 700 10 {lab=vssa}
N 830 10 860 10 {lab=vssa}
N 1000 10 1030 10 {lab=vssa}
N -80 -50 -80 -30 {lab=ref_VUN[7]}
N 100 -50 100 -30 {lab=ref_VUN[6]}
N 270 -50 270 -30 {lab=ref_VUN[5]}
N 450 -50 450 -30 {lab=ref_VUN[4]}
N 610 -50 610 -30 {lab=ref_VUN[3]}
N 780 -50 780 -30 {lab=ref_VUN[2]}
N 940 -50 940 -30 {lab=ref_VUN[1]}
N 1120 -50 1120 -30 {lab=ref_VUN[0]}
C {ISINK.sym} -160 -80 0 0 {name=x2[8:1]}
C {ISINK.sym} 10 -80 0 0 {name=x9[8:1]}
C {ISINK.sym} 180 -80 0 0 {name=x10[8:1]}
C {ISINK.sym} 360 -80 0 0 {name=x11[8:1]}
C {ISINK.sym} 520 -80 0 0 {name=x12[8:1]}
C {ISINK.sym} 690 -80 0 0 {name=x13[8:1]}
C {ISINK.sym} 850 -80 0 0 {name=x14[8:1]}
C {ISINK.sym} 1020 -80 0 0 {name=x8[8:1]}
C {lab_pin.sym} -320 80 0 0 {name=p5 lab=vssa}
C {lab_pin.sym} 1190 -90 0 1 {name=p2 lab=en_VS}
C {iopin.sym} -530 -490 3 1 {name=p1 lab=ref_VUN[7:0]}
C {lab_wire.sym} -130 -320 0 0 {name=p3 sig_type=std_logic lab=ref_VUN[7]}
C {lab_wire.sym} 50 -320 0 0 {name=p4 sig_type=std_logic lab=ref_VUN[6]}
C {lab_wire.sym} 210 -320 0 0 {name=p6 sig_type=std_logic lab=ref_VUN[5]}
C {lab_wire.sym} 400 -320 0 0 {name=p7 sig_type=std_logic lab=ref_VUN[4]}
C {lab_wire.sym} 560 -320 0 0 {name=p8 sig_type=std_logic lab=ref_VUN[3]}
C {lab_wire.sym} 730 -320 0 0 {name=p9 sig_type=std_logic lab=ref_VUN[2]}
C {lab_wire.sym} 890 -320 0 0 {name=p10 sig_type=std_logic lab=ref_VUN[1]}
C {lab_wire.sym} 1070 -320 0 0 {name=p11 sig_type=std_logic lab=ref_VUN[0]}
C {ipin.sym} -290 -470 3 0 {name=p_en lab=en_VS}
C {iopin.sym} -820 -470 1 0 {name=p_vssa1 lab=vssa}
C {cfringe140x6.sym} -80 20 2 1 {name=x1}
C {cfringe140x6.sym} 100 20 2 1 {name=x2}
C {cfringe140x6.sym} 270 20 2 1 {name=x3}
C {cfringe140x6.sym} 450 20 2 1 {name=x4}
C {cfringe140x6.sym} 610 20 2 1 {name=x5}
C {cfringe140x6.sym} 780 20 2 1 {name=x6}
C {cfringe140x6.sym} 940 20 2 1 {name=x7}
C {cfringe140x6.sym} 1120 20 2 1 {name=x8}
