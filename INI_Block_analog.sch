v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -240 460 -200 460 {lab=NNPULEXT_pwbias_VPI}
N -240 480 -200 480 {lab=NNADAP_gain_VPI}
N -240 500 -200 500 {lab=NNADAPDPI_gain_VNI}
N -240 520 -200 520 {lab=NNADAPDPI_lk_VNI}
N -240 540 -200 540 {lab=NNREF_lk_VNI}
N -240 440 -200 440 {lab=NNDPI_lk_VNI}
N -240 420 -200 420 {lab=NNDPI_gain_VNI}
N 100 440 480 440 {lab=#net1}
N 100 480 130 480 {lab=NN1_ADAP_cap_VTO}
N 100 500 130 500 {lab=NN1_REF_cap_VTO}
N -580 400 -200 400 {lab=#net2}
N -580 400 -580 490 {lab=#net2}
N 100 460 330 460 {lab=NN1_REQ}
N -440 560 -200 560 {lab=NN1_ACK}
N -850 460 -770 460 {lab=V2I_INP}
N -810 520 -770 520 {lab=V2I_INN}
N -860 460 -850 460 {lab=V2I_INP}
N -810 250 -810 520 {lab=V2I_INN}
N -860 520 -810 520 {lab=V2I_INN}
N 1620 -1590 1700 -1590 {lab=BIASGEN_en_VS[10:1]
bus=true}
N 1620 -1550 1700 -1550 {lab=BIASGEN_BYP_en_VS[10:1]
bus=true}
N 1620 -1500 1700 -1500 {lab=BIASGEN_EXT_REF_en_VS[10:1]
bus=true}
N -320 -1480 -320 -1300 {lab=reg_out9[10:0] bus=true}
N -360 -1480 -360 -1300 {lab=BIASGEN_en_VS[0]}
N -280 -1480 -280 -1300 {lab=ref_VUN[7:0] bus=true}
N -640 -1480 -640 -1300 {lab=reg_out8[10:0] bus=true}
N -680 -1480 -680 -1300 {lab=BIASGEN_en_VS[0]}
N -600 -1480 -600 -1300 {lab=ref_VUN[7:0] bus=true}
N -970 -1480 -970 -1300 {lab=reg_out7[10:0] bus=true}
N -1010 -1480 -1010 -1300 {lab=BIASGEN_en_VS[0]}
N -930 -1480 -930 -1300 {lab=ref_VUN[7:0] bus=true}
N -1310 -1480 -1310 -1300 {lab=reg_out6[10:0] bus=true}
N -1350 -1480 -1350 -1300 {lab=BIASGEN_en_VS[0]}
N -1270 -1480 -1270 -1300 {lab=ref_VUN[7:0] bus=true}
N -1610 -1480 -1610 -1300 {lab=reg_out5[10:0] bus=true}
N -1650 -1480 -1650 -1300 {lab=BIASGEN_en_VS[0]}
N -1570 -1480 -1570 -1300 {lab=ref_VUN[7:0] bus=true}
N -1900 -1480 -1900 -1300 {lab=reg_out4[10:0] bus=true}
N -1940 -1480 -1940 -1300 {lab=BIASGEN_en_VS[0]}
N -1860 -1480 -1860 -1300 {lab=ref_VUN[7:0] bus=true}
N -2200 -1480 -2200 -1300 {lab=reg_out3[10:0] bus=true}
N -2240 -1480 -2240 -1300 {lab=BIASGEN_en_VS[0]}
N -2160 -1480 -2160 -1300 {lab=ref_VUN[7:0] bus=true}
N -2490 -1480 -2490 -1300 {lab=reg_out2[10:0] bus=true}
N -2530 -1480 -2530 -1300 {lab=BIASGEN_en_VS[0]}
N -2450 -1480 -2450 -1300 {lab=ref_VUN[7:0] bus=true}
N -2780 -1480 -2780 -1300 {lab=reg_out1[10:0] bus=true}
N -2820 -1480 -2820 -1300 {lab=BIASGEN_en_VS[0]}
N -2740 -1480 -2740 -1300 {lab=ref_VUN[7:0] bus=true}
N -850 190 -850 460 {lab=V2I_INP}
N -850 190 -770 190 {lab=V2I_INP}
N -810 250 -770 250 {lab=V2I_INN}
N -850 -90 -850 190 {lab=V2I_INP}
N -850 -90 -770 -90 {lab=V2I_INP}
N -810 -30 -770 -30 {lab=V2I_INN}
N -810 -30 -810 250 {lab=V2I_INN}
N 1500 890 1500 910 {lab=BIASGEN_EXT_REF_en_VS[0]}
N 1460 890 1460 910 {lab=BIASGEN_BYP_en_VS[0]}
N 1480 890 1480 910 {lab=BG_100mV}
N 1440 890 1440 910 {lab=BG_BIAS}
N 1760 560 1760 590 {lab=BG_100kRES}
N -240 200 -200 200 {lab=NNPULEXT_pwbias_VPI}
N -240 220 -200 220 {lab=NNADAP_gain_VPI}
N -240 240 -200 240 {lab=NNADAPDPI_gain_VNI}
N -240 260 -200 260 {lab=NNADAPDPI_lk_VNI}
N -240 280 -200 280 {lab=NNREF_lk_VNI}
N -240 180 -200 180 {lab=NNDPI_lk_VNI}
N -240 160 -200 160 {lab=NNDPI_gain_VNI}
N 100 220 130 220 {lab=NN2_ADAP_cap_VTO}
N 100 240 130 240 {lab=NN2_REF_cap_VTO}
N 100 200 330 200 {lab=NN2_REQ}
N -440 300 -200 300 {lab=NN2_ACK}
N -240 -90 -200 -90 {lab=NNPULEXT_pwbias_VPI}
N -240 -70 -200 -70 {lab=NNADAP_gain_VPI}
N -240 -50 -200 -50 {lab=NNADAPDPI_gain_VNI}
N -240 -30 -200 -30 {lab=NNADAPDPI_lk_VNI}
N -240 -10 -200 -10 {lab=NNREF_lk_VNI}
N -240 -110 -200 -110 {lab=NNDPI_lk_VNI}
N -240 -130 -200 -130 {lab=NNDPI_gain_VNI}
N 100 -110 560 -110 {lab=#net3}
N 100 -70 130 -70 {lab=NN3_ADAP_cap_VTO}
N 100 -50 130 -50 {lab=NN3_REF_cap_VTO}
N -580 -150 -200 -150 {lab=#net4}
N -580 -150 -580 -60 {lab=#net4}
N 100 -90 330 -90 {lab=NN3_REQ}
N -440 10 -200 10 {lab=NN3_ACK}
N -580 140 -200 140 {lab=#net5}
N -580 140 -580 220 {lab=#net5}
N 50 850 150 850 {lab=NN1_MEM_PROB}
N 50 820 50 850 {lab=NN1_MEM_PROB}
N 60 1190 160 1190 {lab=NN2_MEM_PROB}
N 60 1160 60 1190 {lab=NN2_MEM_PROB}
N 60 1550 160 1550 {lab=NN3_MEM_PROB}
N 60 1520 60 1550 {lab=NN3_MEM_PROB}
N -260 820 50 820 {lab=NN1_MEM_PROB}
N -250 1160 60 1160 {lab=NN2_MEM_PROB}
N -250 1520 60 1520 {lab=NN3_MEM_PROB}
N 480 440 480 790 {lab=#net1}
N 150 790 480 790 {lab=#net1}
N 160 1130 520 1130 {lab=#net6}
N 520 180 520 1130 {lab=#net6}
N 100 180 520 180 {lab=#net6}
N 560 -110 560 1490 {lab=#net3}
N 160 1490 560 1490 {lab=#net3}
C {neuron_LVS.sym} -50 490 0 0 {name=x15}
C {lab_pin.sym} -240 440 0 0 {name=p100 sig_type=std_logic lab=NNDPI_lk_VNI}
C {lab_pin.sym} -240 480 0 0 {name=p101 sig_type=std_logic lab=NNADAP_gain_VPI}
C {lab_pin.sym} -240 500 0 0 {name=p102 sig_type=std_logic lab=NNADAPDPI_gain_VNI}
C {lab_pin.sym} -240 520 0 0 {name=p103 sig_type=std_logic lab=NNADAPDPI_lk_VNI}
C {lab_pin.sym} -240 460 0 0 {name=p104 sig_type=std_logic lab=NNPULEXT_pwbias_VPI}
C {lab_pin.sym} -240 420 0 0 {name=p105 sig_type=std_logic lab=NNDPI_gain_VNI}
C {lab_pin.sym} 130 480 2 0 {name=p106 sig_type=std_logic lab=NN1_ADAP_cap_VTO}
C {lab_pin.sym} 130 500 2 0 {name=p108 sig_type=std_logic lab=NN1_REF_cap_VTO}
C {lab_pin.sym} -240 540 0 0 {name=p109 sig_type=std_logic lab=NNREF_lk_VNI}
C {V2I.sym} -710 630 0 0 {name=x16}
C {ipin.sym} -690 560 2 0 {name=p110 sig_type=std_logic lab=VSS
}
C {ipin.sym} -690 420 0 1 {name=p111 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 100 540 0 1 {name=p112 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 100 420 2 0 {name=p113 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} -710 420 1 0 {name=p114 sig_type=std_logic lab=V2I_imax_VPI}
C {opin.sym} 330 460 0 0 {name=p117 lab=NN1_REQ}
C {ipin.sym} -440 560 0 0 {name=p120 lab=NN1_ACK}
C {ipin.sym} -860 520 0 0 {name=p107 lab=V2I_INN}
C {ipin.sym} -860 460 0 0 {name=p145 lab=V2I_INP}
C {lab_pin.sym} 1620 -1590 0 0 {name=p37 sig_type=std_logic lab=BIASGEN_en_VS[10:1]
}
C {noconn.sym} 1850 -1180 0 0 {name=l1}
C {lab_pin.sym} 1620 -1550 0 0 {name=p38 sig_type=std_logic lab=BIASGEN_BYP_en_VS[10:1]
}
C {lab_pin.sym} 1620 -1500 0 0 {name=p41 sig_type=std_logic lab=BIASGEN_EXT_REF_en_VS[10:1]
}
C {noconn.sym} 1850 -1090 0 0 {name=l3}
C {CoreFineDAC_CurrentOutput_N.sym} -260 -1150 1 0 {name=x17}
C {ipin.sym} -320 -1480 1 0 {name=p137 lab=reg_out9[10:0]
}
C {lab_pin.sym} -360 -1480 1 0 {name=p139 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -420 -1150 3 0 {name=p140 lab=VSS
}
C {lab_pin.sym} -200 -1150 1 1 {name=p141 lab=VDD
}
C {lab_pin.sym} -280 -1480 1 0 {name=p142 lab=ref_VUN[7:0]
}
C {opin.sym} -340 -1000 1 0 {name=p158 lab=BG_PROB}
C {noconn.sym} -270 -1000 0 0 {name=l13}
C {CoreDiodeT.sym} 1760 -550 0 0 {name=x1}
C {lab_pin.sym} 1670 -590 0 0 {name=p2 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} 1760 -510 2 0 {name=p3 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 1760 -670 1 0 {name=p4 lab=ref_VUN[7:0]
}
C {CoreFineDAC_N.sym} -580 -1150 1 0 {name=x2}
C {ipin.sym} -640 -1480 1 0 {name=p1 lab=reg_out8[10:0]
}
C {lab_pin.sym} -680 -1480 1 0 {name=p5 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -740 -1150 3 0 {name=p6 lab=VSS
}
C {lab_pin.sym} -520 -1150 1 1 {name=p7 lab=VDD
}
C {lab_pin.sym} -600 -1480 1 0 {name=p8 lab=ref_VUN[7:0]
}
C {noconn.sym} -660 -1000 0 0 {name=l5}
C {lab_pin.sym} -590 -1000 3 0 {name=p9 sig_type=std_logic lab=NNPULEXT_pwbias_VPI}
C {CoreFineDAC_N.sym} -910 -1150 1 0 {name=x10}
C {ipin.sym} -970 -1480 1 0 {name=p46 lab=reg_out7[10:0]
}
C {lab_pin.sym} -1010 -1480 1 0 {name=p47 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -1070 -1150 3 0 {name=p48 lab=VSS
}
C {lab_pin.sym} -850 -1150 1 1 {name=p49 lab=VDD
}
C {lab_pin.sym} -930 -1480 1 0 {name=p50 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -990 -1000 3 0 {name=p71 sig_type=std_logic lab=NNADAPDPI_lk_VNI}
C {noconn.sym} -920 -1000 0 0 {name=l12}
C {CoreFineDAC_N.sym} -1250 -1150 1 0 {name=x9}
C {ipin.sym} -1310 -1480 1 0 {name=p33 lab=reg_out6[10:0]
}
C {lab_pin.sym} -1350 -1480 1 0 {name=p10 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -1410 -1150 3 0 {name=p11 lab=VSS
}
C {lab_pin.sym} -1190 -1150 1 1 {name=p43 lab=VDD
}
C {lab_pin.sym} -1270 -1480 1 0 {name=p44 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -1330 -1000 1 1 {name=p45 sig_type=std_logic lab=NNADAPDPI_gain_VNI}
C {noconn.sym} -1260 -1000 0 0 {name=l6}
C {CoreFineDAC_N.sym} -1550 -1150 1 0 {name=x8}
C {ipin.sym} -1610 -1480 1 0 {name=p34 lab=reg_out5[10:0]
}
C {lab_pin.sym} -1650 -1480 1 0 {name=p35 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -1710 -1150 3 0 {name=p36 lab=VSS
}
C {lab_pin.sym} -1490 -1150 1 1 {name=p12 lab=VDD
}
C {lab_pin.sym} -1570 -1480 1 0 {name=p14 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -1560 -1000 3 0 {name=p40 sig_type=std_logic lab=NNADAP_gain_VPI}
C {noconn.sym} -1630 -1000 0 0 {name=l7}
C {CoreFineDAC_N.sym} -1840 -1150 1 0 {name=x7}
C {ipin.sym} -1900 -1480 1 0 {name=p20 lab=reg_out4[10:0]
}
C {lab_pin.sym} -1940 -1480 1 0 {name=p28 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -2000 -1150 3 0 {name=p29 lab=VSS
}
C {lab_pin.sym} -1780 -1150 1 1 {name=p30 lab=VDD
}
C {lab_pin.sym} -1860 -1480 1 0 {name=p31 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -1920 -1000 3 0 {name=p82 sig_type=std_logic lab=NNREF_lk_VNI}
C {noconn.sym} -1850 -1000 0 0 {name=l9}
C {CoreFineDAC_N.sym} -2140 -1150 1 0 {name=x4}
C {ipin.sym} -2200 -1480 1 0 {name=p15 lab=reg_out3[10:0]
}
C {lab_pin.sym} -2240 -1480 1 0 {name=p16 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -2300 -1150 3 0 {name=p17 lab=VSS
}
C {lab_pin.sym} -2080 -1150 1 1 {name=p18 lab=VDD
}
C {lab_pin.sym} -2160 -1480 1 0 {name=p19 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -2220 -1000 3 0 {name=p27 sig_type=std_logic lab=NNDPI_lk_VNI}
C {noconn.sym} -2150 -1000 0 0 {name=l8}
C {CoreFineDAC_N.sym} -2430 -1150 1 0 {name=x6}
C {ipin.sym} -2490 -1480 1 0 {name=p21 lab=reg_out2[10:0]
}
C {lab_pin.sym} -2530 -1480 1 0 {name=p22 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -2590 -1150 3 0 {name=p23 lab=VSS
}
C {lab_pin.sym} -2370 -1150 1 1 {name=p24 lab=VDD
}
C {lab_pin.sym} -2450 -1480 1 0 {name=p25 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -2510 -1000 3 0 {name=p26 sig_type=std_logic lab=NNDPI_gain_VNI}
C {noconn.sym} -2440 -1000 0 0 {name=l10}
C {CoreFineDAC_N.sym} -2720 -1150 1 0 {name=x12}
C {ipin.sym} -2780 -1480 1 0 {name=p77 lab=reg_out1[10:0]
}
C {lab_pin.sym} -2820 -1480 1 0 {name=p78 lab=BIASGEN_en_VS[0]
}
C {lab_pin.sym} -2880 -1150 3 0 {name=p79 lab=VSS
}
C {lab_pin.sym} -2660 -1150 1 1 {name=p80 lab=VDD
}
C {lab_pin.sym} -2740 -1480 1 0 {name=p81 lab=ref_VUN[7:0]
}
C {lab_pin.sym} -2730 -1000 3 0 {name=p83 sig_type=std_logic lab=V2I_imax_VPI}
C {noconn.sym} -2800 -1000 0 0 {name=l11}
C {V2I.sym} -710 360 0 0 {name=x14}
C {lab_wire.sym} -690 290 2 0 {name=p95 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} -690 150 0 1 {name=p96 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} -710 150 1 0 {name=p99 sig_type=std_logic lab=V2I_imax_VPI}
C {V2I.sym} -710 80 0 0 {name=x3}
C {lab_wire.sym} -690 10 2 0 {name=p32 sig_type=std_logic lab=VSS
}
C {lab_wire.sym} -690 -130 0 1 {name=p39 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} -710 -130 1 0 {name=p51 sig_type=std_logic lab=V2I_imax_VPI}
C {MasterBias.sym} 1560 740 3 0 {name=x5}
C {lab_pin.sym} 1780 590 3 1 {name=p54 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 1300 590 1 0 {name=p55 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 1320 590 1 0 {name=p56 lab=ref_VUN[7]
}
C {lab_pin.sym} 1380 590 1 0 {name=p57 lab=ref_VUN[6]
}
C {lab_pin.sym} 1440 590 1 0 {name=p58 lab=ref_VUN[5]
}
C {lab_pin.sym} 1500 590 1 0 {name=p59 lab=ref_VUN[4]
}
C {lab_pin.sym} 1560 590 1 0 {name=p60 lab=ref_VUN[3]
}
C {lab_pin.sym} 1620 590 1 0 {name=p61 lab=ref_VUN[2]
}
C {lab_pin.sym} 1680 590 1 0 {name=p62 lab=ref_VUN[1]
}
C {lab_pin.sym} 1740 590 1 0 {name=p63 lab=ref_VUN[0]
}
C {lab_pin.sym} 1460 910 3 0 {name=p64 sig_type=std_logic lab=BIASGEN_BYP_en_VS[0]
}
C {lab_pin.sym} 1500 910 3 0 {name=p65 sig_type=std_logic lab=BIASGEN_EXT_REF_en_VS[0]
}
C {ipin.sym} 1480 910 3 0 {name=p66 sig_type=std_logic lab=BG_100mV}
C {ipin.sym} 1440 910 3 0 {name=p67 sig_type=std_logic lab=BG_BIAS}
C {ipin.sym} 1760 560 1 0 {name=p68 sig_type=std_logic lab=BG_100kRES}
C {neuron_LVS.sym} -50 230 0 0 {name=x11}
C {lab_pin.sym} -240 180 0 0 {name=p69 sig_type=std_logic lab=NNDPI_lk_VNI}
C {lab_pin.sym} -240 220 0 0 {name=p70 sig_type=std_logic lab=NNADAP_gain_VPI}
C {lab_pin.sym} -240 240 0 0 {name=p72 sig_type=std_logic lab=NNADAPDPI_gain_VNI}
C {lab_pin.sym} -240 260 0 0 {name=p73 sig_type=std_logic lab=NNADAPDPI_lk_VNI}
C {lab_pin.sym} -240 200 0 0 {name=p74 sig_type=std_logic lab=NNPULEXT_pwbias_VPI}
C {lab_pin.sym} -240 160 0 0 {name=p75 sig_type=std_logic lab=NNDPI_gain_VNI}
C {lab_pin.sym} 130 220 2 0 {name=p76 sig_type=std_logic lab=NN2_ADAP_cap_VTO}
C {lab_pin.sym} 130 240 2 0 {name=p84 sig_type=std_logic lab=NN2_REF_cap_VTO}
C {lab_pin.sym} -240 280 0 0 {name=p85 sig_type=std_logic lab=NNREF_lk_VNI}
C {lab_pin.sym} 100 280 0 1 {name=p86 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 100 160 2 0 {name=p87 sig_type=std_logic lab=VDD
}
C {opin.sym} 330 200 0 0 {name=p88 lab=NN2_REQ}
C {ipin.sym} -440 300 0 0 {name=p89 lab=NN2_ACK}
C {neuron_LVS.sym} -50 -60 0 0 {name=x13}
C {lab_pin.sym} -240 -110 0 0 {name=p91 sig_type=std_logic lab=NNDPI_lk_VNI}
C {lab_pin.sym} -240 -70 0 0 {name=p92 sig_type=std_logic lab=NNADAP_gain_VPI}
C {lab_pin.sym} -240 -50 0 0 {name=p93 sig_type=std_logic lab=NNADAPDPI_gain_VNI}
C {lab_pin.sym} -240 -30 0 0 {name=p94 sig_type=std_logic lab=NNADAPDPI_lk_VNI}
C {lab_pin.sym} -240 -90 0 0 {name=p97 sig_type=std_logic lab=NNPULEXT_pwbias_VPI}
C {lab_pin.sym} -240 -130 0 0 {name=p98 sig_type=std_logic lab=NNDPI_gain_VNI}
C {lab_pin.sym} 130 -70 2 0 {name=p115 sig_type=std_logic lab=NN3_ADAP_cap_VTO}
C {lab_pin.sym} 130 -50 2 0 {name=p116 sig_type=std_logic lab=NN3_REF_cap_VTO}
C {lab_pin.sym} -240 -10 0 0 {name=p118 sig_type=std_logic lab=NNREF_lk_VNI}
C {lab_pin.sym} 100 -10 0 1 {name=p119 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 100 -130 2 0 {name=p121 sig_type=std_logic lab=VDD
}
C {opin.sym} 330 -90 0 0 {name=p122 lab=NN3_REQ}
C {ipin.sym} -440 10 0 0 {name=p123 lab=NN3_ACK}
C {ipin.sym} 160 -1480 1 0 {name=p52 sig_type=std_logic lab=BIASGEN_en_VS[10:0]
}
C {ipin.sym} 120 -1480 1 0 {name=p53 sig_type=std_logic lab=BIASGEN_BYP_en_VS[10:0]
}
C {ipin.sym} 70 -1480 1 0 {name=p125 sig_type=std_logic lab=BIASGEN_EXT_REF_en_VS[10:0]
}
C {opin.sym} 1850 -1180 0 0 {name=p42 sig_type=std_logic lab=C2F_REQ
}
C {opin.sym} 1850 -1090 0 0 {name=p127 sig_type=std_logic lab=C2F_COMP
}
C {noconn.sym} 1850 -1130 0 0 {name=l4}
C {ipin.sym} 1850 -1130 0 1 {name=p128 sig_type=std_logic lab=C2F_ACK
}
C {a_buffP.sym} 80 820 0 1 {name=x18}
C {lab_pin.sym} 80 900 1 1 {name=p129 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 60 740 1 0 {name=p130 sig_type=std_logic lab=VDD
}
C {ipin.sym} 40 900 3 0 {name=p131 sig_type=std_logic lab=MEM_bufferbias
}
C {opin.sym} -260 820 0 1 {name=p132 lab=NN1_MEM_PROB}
C {a_buffP.sym} 90 1160 0 1 {name=x19}
C {lab_pin.sym} 90 1240 1 1 {name=p13 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 70 1080 1 0 {name=p133 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 50 1240 3 0 {name=p134 sig_type=std_logic lab=MEM_bufferbias
}
C {opin.sym} -250 1160 0 1 {name=p135 lab=NN2_MEM_PROB}
C {a_buffP.sym} 90 1520 0 1 {name=x20}
C {lab_pin.sym} 90 1600 1 1 {name=p136 sig_type=std_logic lab=VSS
}
C {lab_pin.sym} 70 1440 1 0 {name=p138 sig_type=std_logic lab=VDD
}
C {lab_pin.sym} 50 1600 3 0 {name=p143 sig_type=std_logic lab=MEM_bufferbias
}
C {opin.sym} -250 1520 0 1 {name=p144 lab=NN3_MEM_PROB}
C {noconn.sym} 1700 -1590 0 1 {name=l15}
C {noconn.sym} 1700 -1500 0 1 {name=l16}
C {noconn.sym} 1700 -1550 0 1 {name=l17}
