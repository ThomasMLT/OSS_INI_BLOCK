v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 870 190 870 360 {lab=vssa}
N 690 130 820 130 {lab=MASTER_biasout_VN}
N 690 0 690 130 {lab=MASTER_biasout_VN}
N 930 -580 1260 -580 {lab=#net1}
N 810 -580 870 -580 {lab=vdda}
N 1300 -580 1360 -580 {lab=vdda}
N 870 -660 1300 -660 {lab=vdda}
N 1300 -660 1300 -610 {lab=vdda}
N 870 -660 870 -610 {lab=vdda}
N 1100 360 1300 360 {lab=vssa}
N 0 360 870 360 {lab=vssa}
N 0 -660 870 -660 {lab=vdda}
N 3000 -270 3070 -270 {lab=vssa}
N 2830 -150 2830 -80 {lab=vssa}
N 2890 -150 2890 -80 {lab=vssa}
N 2950 -150 2950 -80 {lab=vssa}
N 3010 -150 3010 -80 {lab=vssa}
N 2770 -150 2800 -150 {lab=#net2}
N 3040 -150 3070 -150 {lab=#net3}
N 3110 -270 3140 -270 {lab=vdda}
N 2700 -80 2700 -40 {lab=en_VS[0]}
N 2660 -80 2660 10 {lab=en_VSB[0]}
N 2770 -220 2830 -220 {lab=bias_test}
N 2830 -220 2830 -190 {lab=bias_test}
N 2660 -360 3180 -360 {lab=biasgen_VP}
N 1680 -360 1680 -320 {lab=biasgen_VP}
N 1820 -360 1820 -320 {lab=biasgen_VP}
N 1680 -360 1820 -360 {lab=biasgen_VP}
N 1960 -360 1960 -320 {lab=biasgen_VP}
N 1820 -360 1960 -360 {lab=biasgen_VP}
N 2100 -360 2100 -320 {lab=biasgen_VP}
N 1960 -360 2100 -360 {lab=biasgen_VP}
N 2240 -360 2240 -320 {lab=biasgen_VP}
N 2100 -360 2240 -360 {lab=biasgen_VP}
N 2380 -360 2380 -320 {lab=biasgen_VP}
N 2240 -360 2380 -360 {lab=biasgen_VP}
N 2520 -360 2520 -320 {lab=biasgen_VP}
N 2380 -360 2520 -360 {lab=biasgen_VP}
N 2660 -360 2660 -320 {lab=biasgen_VP}
N 2520 -360 2660 -360 {lab=biasgen_VP}
N 3320 -360 3580 -360 {lab=biasgen_VP}
N 2700 -400 3070 -400 {lab=vdda}
N 1720 -400 1720 -320 {lab=vdda}
N 2000 -400 2000 -320 {lab=vdda}
N 2140 -400 2140 -320 {lab=vdda}
N 2280 -400 2280 -320 {lab=vdda}
N 2420 -400 2420 -320 {lab=vdda}
N 2280 -400 2420 -400 {lab=vdda}
N 2560 -400 2560 -320 {lab=vdda}
N 2420 -400 2560 -400 {lab=vdda}
N 2700 -400 2700 -320 {lab=vdda}
N 2560 -400 2700 -400 {lab=vdda}
N 2560 -80 2560 -40 {lab=en_VS[1]}
N 2520 -80 2520 10 {lab=en_VSB[1]}
N 2420 -80 2420 -40 {lab=en_VS[2]}
N 2380 -80 2380 10 {lab=en_VSB[2]}
N 2280 -80 2280 -40 {lab=en_VS[3]}
N 2240 -80 2240 10 {lab=en_VSB[3]}
N 2140 -80 2140 -40 {lab=en_VS[4]}
N 2100 -80 2100 10 {lab=en_VSB[4]}
N 2000 -80 2000 -40 {lab=en_VS[5]}
N 1960 -80 1960 10 {lab=en_VSB[5]}
N 1860 -80 1860 -40 {lab=en_VS[6]}
N 1820 -80 1820 10 {lab=en_VSB[6]}
N 1720 -80 1720 -40 {lab=en_VS[7]}
N 1680 -80 1680 10 {lab=en_VSB[7]}
N 2140 -400 2280 -400 {lab=vdda}
N 1860 -400 2000 -400 {lab=vdda}
N 2000 -400 2140 -400 {lab=vdda}
N 1300 360 1760 360 {lab=vssa}
N 1760 -80 1760 360 {lab=vssa}
N 2600 360 2740 360 {lab=vssa}
N 2740 -80 2740 360 {lab=vssa}
N 2600 -80 2600 360 {lab=vssa}
N 2460 360 2600 360 {lab=vssa}
N 2460 -80 2460 360 {lab=vssa}
N 2320 360 2460 360 {lab=vssa}
N 2320 -80 2320 360 {lab=vssa}
N 2180 360 2320 360 {lab=vssa}
N 2180 -80 2180 360 {lab=vssa}
N 2040 360 2180 360 {lab=vssa}
N 2040 -80 2040 360 {lab=vssa}
N 1900 360 2040 360 {lab=vssa}
N 1900 -80 1900 360 {lab=vssa}
N 1760 360 1900 360 {lab=vssa}
N 1300 -660 1720 -660 {lab=vdda}
N 1720 -660 1720 -400 {lab=vdda}
N 3070 -240 3070 -150 {lab=#net3}
N 3070 -400 3070 -300 {lab=vdda}
N 3010 -220 3010 -190 {lab=bias_test}
N 2950 -220 3010 -220 {lab=bias_test}
N 2890 -220 2890 -190 {lab=bias_test}
N 2830 -220 2890 -220 {lab=bias_test}
N 2950 -220 2950 -190 {lab=bias_test}
N 2890 -220 2950 -220 {lab=bias_test}
N 3440 -660 3440 -600 {lab=vdda}
N 3180 -660 3180 -600 {lab=vdda}
N 1720 -660 3180 -660 {lab=vdda}
N 3180 -540 3180 -470 {lab=#net4}
N 3440 -540 3440 -470 {lab=#net5}
N 3340 -570 3400 -570 {lab=biasgen_VP}
N 3290 -570 3320 -570 {lab=biasgen_VP}
N 3180 -410 3180 -360 {lab=biasgen_VP}
N 3440 -60 3440 20 {lab=biasgen_VN}
N 3340 -660 3440 -660 {lab=vdda}
N 3440 170 3440 360 {lab=vssa}
N 3440 -410 3440 -60 {lab=biasgen_VN}
N 3300 310 3300 360 {lab=vssa}
N 3300 360 3440 360 {lab=vssa}
N 3440 -60 3580 -60 {lab=biasgen_VN}
N 1860 -400 1860 -320 {lab=vdda}
N 1720 -400 1860 -400 {lab=vdda}
N 930 -580 930 -510 {lab=#net1}
N 870 -510 930 -510 {lab=#net1}
N 910 -580 930 -580 {lab=#net1}
N 870 -550 870 -510 {lab=#net1}
N 3440 -570 3500 -570 {lab=vdda}
N 3440 -440 3500 -440 {lab=vdda}
N 3120 -570 3180 -570 {lab=vdda}
N 3120 -440 3180 -440 {lab=vdda}
N 870 -510 870 40 {lab=#net1}
N 1300 -550 1300 -220 {lab=bias_test}
N 3180 -360 3320 -360 {lab=biasgen_VP}
N 3220 -500 3220 -440 {lab=MASTER_CoreDiodeT_bias_VN[2]}
N 3400 -500 3580 -500 {lab=MASTER_CoreDiodeT_bias_VN[2]}
N 3400 -500 3400 -440 {lab=MASTER_CoreDiodeT_bias_VN[2]}
N 2740 360 3300 360 {lab=vssa}
N 3300 110 3300 250 {lab=biasgen_VN}
N 3300 110 3370 110 {lab=biasgen_VN}
N 3300 -60 3300 110 {lab=biasgen_VN}
N 3300 -60 3440 -60 {lab=biasgen_VN}
N 3240 70 3370 70 {lab=BIASGEN_en_VS}
N 1230 -30 1300 -30 {lab=vssa}
N 1230 150 1300 150 {lab=vssa}
N 1340 -30 1370 -30 {lab=bias_test}
N 1340 150 1370 150 {lab=#net6}
N 1370 -220 1650 -220 {lab=bias_test}
N 1300 180 1300 360 {lab=vssa}
N 1370 -220 1370 -30 {lab=bias_test}
N 1300 -220 1370 -220 {lab=bias_test}
N 1100 -150 1650 -150 {lab=V_drain_ISINK}
N 1100 -150 1100 -90 {lab=V_drain_ISINK}
N 1100 60 1100 360 {lab=vssa}
N 870 360 1100 360 {lab=vssa}
N 690 -0 1090 -0 {lab=MASTER_biasout_VN}
N 3320 -570 3320 -360 {lab=biasgen_VP}
N 3220 -500 3400 -500 {lab=MASTER_CoreDiodeT_bias_VN[2]}
N 1300 -220 1300 -60 {lab=bias_test}
N 1300 60 1300 120 {lab=#net6}
N 1370 60 1370 150 {lab=#net6}
N 1300 60 1370 60 {lab=#net6}
N 1300 0 1300 60 {lab=#net6}
N -800 600 -680 600 {lab=MASTER_CoreDiodeT_bias_VN[7]}
N -830 440 -680 440 {lab=MASTER_CoreDiodeT_bias_VN[6]}
N -860 280 -680 280 {lab=MASTER_CoreDiodeT_bias_VN[5]}
N -890 120 -680 120 {lab=MASTER_CoreDiodeT_bias_VN[4]}
N -920 -40 -680 -40 {lab=MASTER_CoreDiodeT_bias_VN[3]}
N -950 -200 -680 -200 {lab=MASTER_CoreDiodeT_bias_VN[2]}
N -980 -360 -680 -360 {lab=MASTER_CoreDiodeT_bias_VN[1]}
N -1010 -520 -680 -520 {lab=MASTER_CoreDiodeT_bias_VN[0]}
N 870 190 900 190 {lab=vssa}
N 870 40 900 40 {lab=#net1}
N 790 90 820 90 {lab=BIASGEN_en_VS}
N 1100 -90 1170 -90 {lab=V_drain_ISINK}
N 1100 60 1170 60 {lab=vssa}
N 1020 -40 1090 -40 {lab=BIASGEN_en_VS}
N 3440 20 3450 20 {lab=biasgen_VN}
N 3440 170 3450 170 {lab=vssa}
N -590 500 -480 500 {lab=#net7}
N -590 180 -480 180 {lab=#net8}
N -590 -140 -480 -140 {lab=#net9}
N -590 -460 -480 -460 {lab=#net10}
N -350 320 -280 320 {lab=#net11}
N -350 -320 -280 -320 {lab=#net12}
N -170 -320 -170 0 {lab=MASTER_biasout_VN}
N -170 0 690 0 {lab=MASTER_biasout_VN}
N -170 0 -170 320 {lab=MASTER_biasout_VN}
N -650 480 -650 530 {lab=en_VSB[8]}
N -650 640 -650 680 {lab=en_VS[8]}
N -650 320 -650 360 {lab=en_VS[8]}
N -650 160 -650 210 {lab=en_VSB[8]}
N -650 0 -650 40 {lab=en_VS[8]}
N -650 -320 -650 -300 {lab=en_VS[8]}
N -650 -480 -650 -450 {lab=en_VSB[8]}
N -650 -160 -650 -110 {lab=en_VSB[8]}
N -450 540 -450 580 {lab=en_VS[9]}
N -450 220 -450 270 {lab=en_VSB[9]}
N -450 -100 -450 -60 {lab=en_VS[9]}
N -450 -420 -450 -370 {lab=en_VSB[9]}
N -250 -280 -250 -230 {lab=en_VSB[10]}
N -250 360 -250 380 {lab=en_VS[10]}
N -590 -200 -590 -140 {lab=#net9}
N -590 -140 -590 -40 {lab=#net9}
N -590 120 -590 180 {lab=#net8}
N -590 180 -590 280 {lab=#net8}
N -590 440 -590 500 {lab=#net7}
N -590 500 -590 600 {lab=#net7}
N -350 180 -350 320 {lab=#net11}
N -350 320 -350 500 {lab=#net11}
N -590 -520 -590 -460 {lab=#net10}
N -590 -460 -590 -360 {lab=#net10}
N -350 -460 -350 -320 {lab=#net12}
N -350 -320 -350 -140 {lab=#net12}
N -620 -200 -590 -200 {lab=#net9}
N -620 -360 -590 -360 {lab=#net10}
N -620 -520 -590 -520 {lab=#net10}
N -420 500 -350 500 {lab=#net11}
N -620 600 -590 600 {lab=#net7}
N -620 440 -590 440 {lab=#net7}
N -620 280 -590 280 {lab=#net8}
N -620 120 -590 120 {lab=#net8}
N -620 -40 -590 -40 {lab=#net9}
N -420 -460 -350 -460 {lab=#net12}
N -420 -140 -350 -140 {lab=#net12}
N -420 180 -350 180 {lab=#net11}
N -220 -320 -170 -320 {lab=MASTER_biasout_VN}
N -220 320 -170 320 {lab=MASTER_biasout_VN}
N 3340 -590 3340 -570 {lab=biasgen_VP}
N 3320 -570 3340 -570 {lab=biasgen_VP}
N 3290 -590 3290 -570 {lab=biasgen_VP}
N 3250 -570 3290 -570 {lab=biasgen_VP}
N 3290 -660 3290 -650 {lab=vdda}
N 3250 -660 3290 -660 {lab=vdda}
N 3340 -660 3340 -650 {lab=vdda}
N 3290 -660 3340 -660 {lab=vdda}
N 3250 -590 3250 -570 {lab=biasgen_VP}
N 3220 -570 3250 -570 {lab=biasgen_VP}
N 3250 -660 3250 -650 {lab=vdda}
N 3180 -660 3250 -660 {lab=vdda}
N 3080 310 3300 310 {lab=vssa}
N 3080 250 3300 250 {lab=biasgen_VN}
N -630 -2330 -580 -2330 {lab=vdda}
N -630 -2440 -580 -2440 {lab=vdda}
N -580 -2440 -580 -2410 {lab=vdda}
N -580 -2410 -540 -2410 {lab=vdda}
N -540 -2440 -540 -2410 {lab=vdda}
N -580 -2330 -580 -2300 {lab=vdda}
N -580 -2300 -540 -2300 {lab=vdda}
N -540 -2330 -540 -2300 {lab=vdda}
C {iopin.sym} 0 360 2 0 {name=p8 sig_type=std_logic lab=vssa
}
C {ISINK.sym} 850 100 0 1 {name=xisink0}
C {lab_wire.sym} 790 90 0 0 {name=p3 sig_type=std_logic lab=BIASGEN_en_VS
}
C {sg13g2_pr/sg13_hv_pmos.sym} 890 -580 0 1 {name=M1
l=1u
w=2u
ng=2
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} 1280 -580 0 0 {name=M2
l=1u
w=2u
ng=2
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {lab_wire.sym} 810 -580 0 0 {name=p4 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 1360 -580 0 1 {name=p5 sig_type=std_logic lab=vdda
}
C {iopin.sym} 0 -660 0 1 {name=p7 sig_type=std_logic lab=vdda
}
C {SplitterCell.sym} 2760 -150 0 0 {name=x4}
C {lab_wire.sym} 1300 -220 0 0 {name=p13 sig_type=std_logic lab=bias_test
}
C {sg13g2_pr/sg13_hv_nmos.sym} 3090 -270 0 1 {name=M_enb
l=1u
w=1u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3000 -270 0 0 {name=p_en_g2 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} 2830 -170 3 1 {name=M_s9
l=10u
w=2u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2830 -80 3 0 {name=p_en_g11 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} 2890 -170 3 1 {name=M_s10
l=10u
w=2u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2890 -80 3 0 {name=p_en_g12 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} 2950 -170 3 1 {name=M_s11
l=10u
w=2u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2950 -80 3 0 {name=p_en_g13 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} 3010 -170 3 1 {name=M_s12
l=10u
w=2u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3010 -80 3 0 {name=p_en_g14 sig_type=std_logic lab=vssa}
C {lab_wire.sym} 3140 -270 2 0 {name=p21 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 2700 -40 0 1 {name=p22 sig_type=std_logic lab=en_VS[0]
}
C {lab_wire.sym} 2660 10 0 0 {name=p23 sig_type=std_logic lab=en_VSB[0]
}
C {SplitterCell.sym} 2620 -150 0 0 {name=x5}
C {SplitterCell.sym} 2480 -150 0 0 {name=x6}
C {SplitterCell.sym} 2340 -150 0 0 {name=x7}
C {SplitterCell.sym} 2200 -150 0 0 {name=x8}
C {SplitterCell.sym} 2060 -150 0 0 {name=x9}
C {SplitterCell.sym} 1920 -150 0 0 {name=x10}
C {SplitterCell.sym} 1780 -150 0 0 {name=x11}
C {lab_wire.sym} 2560 -40 0 1 {name=p40 sig_type=std_logic lab=en_VS[1]
}
C {lab_wire.sym} 2520 10 0 0 {name=p41 sig_type=std_logic lab=en_VSB[1]
}
C {lab_wire.sym} 2420 -40 0 1 {name=p45 sig_type=std_logic lab=en_VS[2]
}
C {lab_wire.sym} 2280 -40 0 1 {name=p50 sig_type=std_logic lab=en_VS[3]
}
C {lab_wire.sym} 2240 10 0 0 {name=p51 sig_type=std_logic lab=en_VSB[3]
}
C {lab_wire.sym} 2140 -40 0 1 {name=p55 sig_type=std_logic lab=en_VS[4]
}
C {lab_wire.sym} 2100 10 0 0 {name=p56 sig_type=std_logic lab=en_VSB[4]
}
C {lab_wire.sym} 2000 -40 0 1 {name=p60 sig_type=std_logic lab=en_VS[5]
}
C {lab_wire.sym} 1960 10 0 0 {name=p61 sig_type=std_logic lab=en_VSB[5]
}
C {lab_wire.sym} 1860 -40 0 1 {name=p65 sig_type=std_logic lab=en_VS[6]
}
C {lab_wire.sym} 1820 10 0 0 {name=p66 sig_type=std_logic lab=en_VSB[6]
}
C {lab_wire.sym} 1720 -40 0 1 {name=p70 sig_type=std_logic lab=en_VS[7]
}
C {lab_wire.sym} 1680 10 0 0 {name=p71 sig_type=std_logic lab=en_VSB[7]
}
C {lab_wire.sym} 2380 10 0 0 {name=p42 sig_type=std_logic lab=en_VSB[2]
}
C {sg13g2_pr/sg13_hv_pmos.sym} 3200 -570 0 1 {name=M8
l=1u
w=4u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} 3420 -570 0 0 {name=M7
l=1u
w=4u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} 3200 -440 0 1 {name=M9
l=0.5u
w=4u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} 3420 -440 0 0 {name=M10
l=0.5u
w=4u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {ISINK.sym} 3420 80 0 1 {name=xisink10}
C {opin.sym} 3580 -360 0 0 {name=p_en_cbb5 lab=biasgen_VP}
C {opin.sym} 3580 -60 0 0 {name=p_en_cbb6 lab=biasgen_VN}
C {lab_wire.sym} 3500 -570 0 1 {name=p15 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 3500 -440 0 1 {name=p16 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 3120 -570 2 1 {name=p17 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 3120 -440 2 1 {name=p24 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 690 0 3 1 {name=p26 sig_type=std_logic lab=MASTER_biasout_VN
}
C {ipin.sym} 3240 70 0 0 {name=p27 sig_type=std_logic lab=BIASGEN_en_VS
}
C {lab_wire.sym} 1230 -30 0 0 {name=p_en_g1 sig_type=std_logic lab=vssa}
C {sg13g2_pr/sg13_hv_nmos.sym} 1320 -30 0 1 {name=M_b4
l=6u
w=2u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1230 150 0 0 {name=p_en_g5 sig_type=std_logic lab=vssa}
C {ISINK.sym} 1080 -30 0 1 {name=xisink1}
C {lab_wire.sym} 1020 -40 0 0 {name=p1 sig_type=std_logic lab=BIASGEN_en_VS
}
C {lab_wire.sym} 1100 -150 0 0 {name=p2 sig_type=std_logic lab=V_drain_ISINK
}
C {lab_wire.sym} 3580 -500 0 1 {name=p9 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[2]
}
C {sg13g2_pr/sg13_hv_nmos.sym} 1320 150 0 1 {name=M_b3
l=6u
w=2u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {ipin.sym} -800 600 3 0 {name=p11 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[7]
}
C {ipin.sym} -830 440 3 0 {name=p53 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[6]
}
C {ipin.sym} -860 280 3 0 {name=p54 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[5]
}
C {ipin.sym} -890 120 3 0 {name=p12 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[4]
}
C {ipin.sym} -920 -40 3 0 {name=p28 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[3]
}
C {ipin.sym} -980 -360 3 0 {name=p57 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[1]
}
C {ipin.sym} -950 -200 3 0 {name=p58 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[2]
}
C {ipin.sym} -1010 -520 3 0 {name=p59 sig_type=std_logic lab=MASTER_CoreDiodeT_bias_VN[0]
}
C {ipin.sym} 700 -950 0 0 {name=p29 sig_type=std_logic lab=en_VS[0]
}
C {lab_wire.sym} 760 -1000 0 1 {name=p36 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -900 0 1 {name=p37 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -950 0 0 {name=xinv1}
C {lab_wire.sym} 830 -950 0 1 {name=p38 sig_type=std_logic lab=en_VSB[0]
}
C {ipin.sym} 700 -1100 0 0 {name=p39 sig_type=std_logic lab=en_VS[1]
}
C {lab_wire.sym} 760 -1150 0 1 {name=p43 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1050 0 1 {name=p44 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1100 0 0 {name=xinv2}
C {lab_wire.sym} 830 -1100 0 1 {name=p46 sig_type=std_logic lab=en_VSB[1]
}
C {ipin.sym} 700 -1230 0 0 {name=p47 sig_type=std_logic lab=en_VS[2]
}
C {lab_wire.sym} 760 -1280 0 1 {name=p48 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1180 0 1 {name=p49 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1230 0 0 {name=xinv3}
C {lab_wire.sym} 830 -1230 0 1 {name=p52 sig_type=std_logic lab=en_VSB[2]
}
C {ipin.sym} 700 -1360 0 0 {name=p62 sig_type=std_logic lab=en_VS[3]
}
C {lab_wire.sym} 760 -1410 0 1 {name=p63 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1310 0 1 {name=p64 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1360 0 0 {name=xinv4}
C {lab_wire.sym} 830 -1360 0 1 {name=p67 sig_type=std_logic lab=en_VSB[3]
}
C {ipin.sym} 700 -1490 0 0 {name=p68 sig_type=std_logic lab=en_VS[4]
}
C {lab_wire.sym} 760 -1540 0 1 {name=p69 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1440 0 1 {name=p72 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1490 0 0 {name=xinv5}
C {lab_wire.sym} 830 -1490 0 1 {name=p73 sig_type=std_logic lab=en_VSB[4]
}
C {ipin.sym} 700 -1620 0 0 {name=p74 sig_type=std_logic lab=en_VS[5]
}
C {lab_wire.sym} 760 -1670 0 1 {name=p76 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1570 0 1 {name=p77 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1620 0 0 {name=xinv6}
C {lab_wire.sym} 830 -1620 0 1 {name=p78 sig_type=std_logic lab=en_VSB[5]
}
C {ipin.sym} 700 -1750 0 0 {name=p79 sig_type=std_logic lab=en_VS[6]
}
C {lab_wire.sym} 760 -1800 0 1 {name=p80 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1700 0 1 {name=p81 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1750 0 0 {name=xinv7}
C {lab_wire.sym} 830 -1750 0 1 {name=p82 sig_type=std_logic lab=en_VSB[6]
}
C {ipin.sym} 700 -1880 0 0 {name=p83 sig_type=std_logic lab=en_VS[7]
}
C {lab_wire.sym} 760 -1930 0 1 {name=p84 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1830 0 1 {name=p85 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -1880 0 0 {name=xinv8}
C {lab_wire.sym} 830 -1880 0 1 {name=p86 sig_type=std_logic lab=en_VSB[7]
}
C {ipin.sym} 700 -2010 0 0 {name=p87 sig_type=std_logic lab=en_VS[8]
}
C {lab_wire.sym} 760 -2060 0 1 {name=p88 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -1960 0 1 {name=p89 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -2010 0 0 {name=xinv9}
C {lab_wire.sym} 830 -2010 0 1 {name=p90 sig_type=std_logic lab=en_VSB[8]
}
C {ipin.sym} 700 -2140 0 0 {name=p91 sig_type=std_logic lab=en_VS[9]
}
C {lab_wire.sym} 760 -2190 0 1 {name=p92 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -2090 0 1 {name=p93 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -2140 0 0 {name=xinv10}
C {lab_wire.sym} 830 -2140 0 1 {name=p94 sig_type=std_logic lab=en_VSB[9]
}
C {ipin.sym} 700 -2270 0 0 {name=p18 sig_type=std_logic lab=en_VS[10]
}
C {lab_wire.sym} 760 -2320 0 1 {name=p19 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} 760 -2220 0 1 {name=p20 sig_type=std_logic lab=vssa
}
C {inv_BG.sym} 850 -2270 0 0 {name=xinv11}
C {lab_wire.sym} 830 -2270 0 1 {name=p75 sig_type=std_logic lab=en_VSB[10]
}
C {ISINK.sym} 880 100 0 1 {name=xisink3}
C {ISINK.sym} 1090 -30 0 1 {name=xisink2}
C {ISINK.sym} 1100 -30 0 1 {name=xisink4}
C {ISINK.sym} 1110 -30 0 1 {name=xisink5}
C {ISINK.sym} 1120 -30 0 1 {name=xisink6}
C {ISINK.sym} 1130 -30 0 1 {name=xisink7}
C {ISINK.sym} 1140 -30 0 1 {name=xisink8}
C {ISINK.sym} 1150 -30 0 1 {name=xisink9}
C {ISINK.sym} 3430 80 0 1 {name=xisink11}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 620 3 0 {name=MUX_L0_0
l=0.45u
w=4.98u
ng=6
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 460 3 0 {name=MUX_L0_1
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 300 3 0 {name=MUX_L0_2
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 140 3 0 {name=MUX_L0_3
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 -20 3 0 {name=MUX_L0_4
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 -180 3 0 {name=MUX_L0_5
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 -340 3 0 {name=MUX_L0_6
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -650 -500 3 0 {name=MUX_L0_7
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -450 520 3 0 {name=MUX_L1_A
l=0.45u
w=4.98u
ng=6
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -450 200 3 0 {name=MUX_L1_B
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -450 -120 3 0 {name=MUX_L1_C
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -450 -440 3 0 {name=MUX_L1_D
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -250 340 3 0 {name=MUX_L2_A
l=0.45u
w=5u
ng=2
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -250 -300 3 0 {name=MUX_L2_B
l=10u
w=0.45u
ng=1
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -650 640 3 0 {name=p_en0_a sig_type=std_logic lab=en_VS[8]}
C {lab_wire.sym} -650 480 3 0 {name=p_en0_b sig_type=std_logic lab=en_VSB[8]}
C {lab_wire.sym} -650 320 3 0 {name=p_en0_c sig_type=std_logic lab=en_VS[8]}
C {lab_wire.sym} -650 160 3 0 {name=p_en0_d sig_type=std_logic lab=en_VSB[8]}
C {lab_wire.sym} -650 0 3 0 {name=p_en0_e sig_type=std_logic lab=en_VS[8]}
C {lab_wire.sym} -650 -160 3 0 {name=p_en0_f sig_type=std_logic lab=en_VSB[8]}
C {lab_wire.sym} -650 -320 3 0 {name=p_en0_g sig_type=std_logic lab=en_VS[8]}
C {lab_wire.sym} -650 -480 3 0 {name=p_en0_h sig_type=std_logic lab=en_VSB[8]}
C {lab_wire.sym} -450 540 3 0 {name=p_en1_a sig_type=std_logic lab=en_VS[9]}
C {lab_wire.sym} -450 220 3 0 {name=p_en1_b sig_type=std_logic lab=en_VSB[9]}
C {lab_wire.sym} -450 -100 3 0 {name=p_en1_c sig_type=std_logic lab=en_VS[9]}
C {lab_wire.sym} -450 -420 3 0 {name=p_en1_d sig_type=std_logic lab=en_VSB[9]}
C {lab_wire.sym} -250 360 3 0 {name=p_en2_a sig_type=std_logic lab=en_VS[10]}
C {lab_wire.sym} -250 -280 3 0 {name=p_en2_b sig_type=std_logic lab=en_VSB[10]}
C {lab_wire.sym} -650 -200 3 1 {name=p_en1 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -450 -140 3 1 {name=p_en2 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 -40 3 1 {name=p_en3 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 120 3 1 {name=p_en4 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 280 3 1 {name=p_en5 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -450 180 3 1 {name=p_en6 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -250 320 3 1 {name=p_en7 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -450 500 3 1 {name=p_en8 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 440 3 1 {name=p_en9 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 600 3 1 {name=p_en10 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -250 -320 3 1 {name=p_en11 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -450 -460 3 1 {name=p_en12 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 -360 3 1 {name=p_en13 sig_type=std_logic lab=vssa}
C {lab_wire.sym} -650 -520 3 1 {name=p_en14 sig_type=std_logic lab=vssa}
C {sg13g2_pr/cap_mfringe.sym} 3290 -620 2 0 {name=C1
model=cap_mfringe
w=9.3750u
l=11.26u
mmin=1
mmax=4
spiceprefix=X
}
C {sg13g2_pr/cap_mfringe.sym} 3300 280 0 0 {name=C2
model=cap_mfringe
w=4.44u
l=5u
mmin=1
mmax=4
spiceprefix=X
}
C {sg13g2_pr/cap_mfringe.sym} 3340 -620 2 0 {name=C3
model=cap_mfringe
w=9.3750u
l=22.5u
mmin=1
mmax=4
spiceprefix=X
}
C {sg13g2_pr/cap_mfringe.sym} 3250 -620 2 0 {name=C4
model=cap_mfringe
w=15u
l=36.5u
mmin=1
mmax=4
spiceprefix=X
}
C {sg13g2_pr/cap_mfringe.sym} 3190 280 0 0 {name=C5
model=cap_mfringe
w=8.96u
l=19.18u
mmin=1
mmax=4
spiceprefix=X
}
C {sg13g2_pr/cap_mfringe.sym} 3080 280 2 0 {name=C6
model=cap_mfringe
w=19.73u
l=31u
mmin=1
mmax=4
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} -560 -2440 0 1 {name=M3
l=0.45u
w=4u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_pmos.sym} -560 -2330 0 1 {name=M4
l=0.45u
w=4u
ng=1
m=2
model=sg13_hv_pmos
spiceprefix=X
}
C {lab_wire.sym} -630 -2440 2 1 {name=p6 sig_type=std_logic lab=vdda
}
C {lab_wire.sym} -630 -2330 2 1 {name=p10 sig_type=std_logic lab=vdda
}
C {lab_pin.sym} -580 -2360 0 0 {name=p_en_cbb1 lab=biasgen_VN}
C {lab_pin.sym} -580 -2470 0 0 {name=p_en_cbb2 lab=biasgen_VP}
