v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 1 1 -1910 -270 {}
P 1 1 -1750 -160 {}
P 4 1 -1670 -150 {}
N 60 -140 60 -60 {lab=VSSA}
N 300 -140 300 -60 {lab=VSSA}
N 540 -140 540 -70 {lab=VSSA}
N 780 -140 780 -70 {lab=VSSA}
N 1020 -140 1020 -80 {lab=VSSA}
N 1260 -140 1260 -70 {lab=VSSA}
N 1500 -140 1500 -80 {lab=VSSA}
N 160 -130 160 20 {lab=IREF_100nA}
N 400 -130 400 20 {lab=IREF_10nA}
N 640 -130 640 20 {lab=IREF_1nA}
N 880 -130 880 20 {lab=IREF_100pA}
N 1120 -130 1120 20 {lab=IREF_10pA}
N 1360 -130 1360 20 {lab=IREF_1pA}
N 1600 -130 1600 20 {lab=IREF_100fA}
N 1690 -270 1820 -270 {lab=#net1}
N 240 -270 250 -270 {lab=#net2}
N 480 -270 490 -270 {lab=#net3}
N 720 -270 730 -270 {lab=#net4}
N 960 -270 970 -270 {lab=#net5}
N 1200 -270 1210 -270 {lab=#net6}
N 1440 -270 1450 -270 {lab=#net7}
N -2250 -30 -2250 80 {lab=VSSA}
N -2320 -390 -2320 -320 {lab=VDDA}
N -2520 -30 -2320 -30 {lab=IREF_1uA}
N -1270 100 -1270 170 {lab=EXT_REF_EN}
N -1860 -90 -1860 -50 {lab=VSSA}
N -1630 -130 -1630 60 {lab=#net8}
N -1500 -360 -1500 -330 {lab=VSSA}
N -1630 -160 -1570 -160 {lab=VSSA}
N -2320 -460 -1860 -460 {lab=VDDA}
N -2590 -460 -2320 -460 {lab=VDDA}
N -1360 -270 0 -270 {lab=#net9}
N -1860 -460 -1860 -230 {lab=VDDA}
N -1630 -270 -1630 -190 {lab=#net9}
N -2150 -160 -2150 60 {lab=#net8}
N -2150 60 -1630 60 {lab=#net8}
N -1360 -270 -1360 -190 {lab=#net9}
N -1630 -270 -1360 -270 {lab=#net9}
N -1630 60 -1360 60 {lab=#net8}
N -1360 -130 -1360 60 {lab=#net8}
N -1440 -160 -1400 -160 {lab=BYP_EN}
N -1360 -160 -1260 -160 {lab=VSSA}
N -1630 60 -1630 170 {lab=#net8}
N -1780 200 -1670 200 {lab=EXT_REF_ENB}
N -1360 60 -1300 60 {lab=#net8}
N -1240 60 -1140 60 {lab=VREG_pad}
N -1630 380 -1630 420 {lab=VSSA}
N -1630 220 -1630 320 {lab=VSENSE}
N -2670 -460 -2590 -460 {lab=VDDA}
N -2590 -280 -2590 -260 {lab=VSSA}
N -2520 -330 -2470 -330 {lab=EXT_REF_ENB}
N -1630 200 -1550 200 {lab=VSSA}
N -1270 -10 -1270 60 {lab=VSSA}
N -1750 -160 -1670 -160 {lab=VBIAS}
N -1820 -10 -1750 -10 {lab=VBIAS}
N -1750 -160 -1750 -10 {lab=VBIAS}
N -1760 -160 -1750 -160 {lab=VBIAS}
N -2150 -160 -1920 -160 {lab=#net8}
N 200 -460 200 -340 {lab=VDDA}
N 440 -460 440 -340 {lab=VDDA}
N 680 -460 680 -340 {lab=VDDA}
N 920 -460 920 -340 {lab=VDDA}
N 1160 -460 1160 -340 {lab=VDDA}
N 1400 -460 1400 -340 {lab=VDDA}
N 1640 -460 1640 -340 {lab=VDDA}
N -1860 -460 200 -460 {lab=VDDA}
N 200 -460 440 -460 {lab=VDDA}
N 440 -460 680 -460 {lab=VDDA}
N 680 -460 920 -460 {lab=VDDA}
N 920 -460 1160 -460 {lab=VDDA}
N 1160 -460 1400 -460 {lab=VDDA}
N 1400 -460 1640 -460 {lab=VDDA}
N -2180 -270 -1630 -270 {lab=#net9}
N -2320 -390 -2180 -390 {lab=VDDA}
N -2320 -460 -2320 -390 {lab=VDDA}
N -2180 -280 -2180 -270 {lab=#net9}
N -2210 -270 -2180 -270 {lab=#net9}
N -2590 -460 -2590 -380 {lab=VDDA}
N -2780 -330 -2650 -330 {lab=EXT_REF_EN}
N -2180 -390 -2180 -380 {lab=VDDA}
C {lab_wire.sym} 60 -80 1 0 {name=p4 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} 300 -80 1 0 {name=p1 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} 540 -80 1 0 {name=p2 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} 780 -80 1 0 {name=p3 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} 1020 -80 1 0 {name=p5 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} 1260 -80 1 0 {name=p6 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} 1500 -90 1 0 {name=p7 sig_type=std_logic lab=VSSA}
C {iopin.sym} 160 20 1 0 {name=p24 lab=IREF_100nA}
C {iopin.sym} 400 20 1 0 {name=p8 lab=IREF_10nA}
C {iopin.sym} 640 20 1 0 {name=p9 lab=IREF_1nA}
C {iopin.sym} 880 20 1 0 {name=p10 lab=IREF_100pA}
C {iopin.sym} 1120 20 1 0 {name=p11 lab=IREF_10pA}
C {iopin.sym} 1360 20 1 0 {name=p12 lab=IREF_1pA}
C {iopin.sym} 1600 20 1 0 {name=p13 lab=IREF_100fA}
C {lab_wire.sym} -2250 20 1 0 {name=p15 sig_type=std_logic lab=VSSA}
C {iopin.sym} -1630 420 1 0 {name=p_vssa lab=VSSA}
C {iopin.sym} -2520 -30 2 0 {name=p16 lab=IREF_1uA}
C {sg13g2_pr/sg13_hv_nmos.sym} -1270 80 1 1 {name=Mnbias
l=500n
w=25u
ng=20
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -1860 -60 1 0 {name=p_vssa_ota sig_type=std_logic lab=VSSA}
C {lab_wire.sym} -1500 -340 1 0 {name=p_cbyp1_vssa sig_type=std_logic lab=VSSA}
C {lab_wire.sym} -1280 -160 1 0 {name=p_byp_vssa sig_type=std_logic lab=VSSA}
C {lab_wire.sym} -1700 -160 0 0 {name=p_vbias_lbl sig_type=std_logic lab=VBIAS}
C {ipin.sym} -1920 -130 0 0 {name=p_vref lab=VREF_100mV}
C {ipin.sym} -1920 -190 0 0 {name=p_vbptia lab=VBP_TIA}
C {iopin.sym} -2670 -460 0 1 {name=p_vdda_ext lab=VDDA}
C {lab_wire.sym} -1590 -160 1 0 {name=p_vssa_ota1 sig_type=std_logic lab=VSSA}
C {ipin.sym} -1440 -160 0 0 {name=p_vbptia1 lab=BYP_EN}
C {lab_wire.sym} -1270 160 1 0 {name=p14 sig_type=std_logic lab=EXT_REF_EN}
C {lab_wire.sym} -1770 200 2 0 {name=p17 sig_type=std_logic lab=EXT_REF_ENB}
C {inv_BG.sym} -2500 -330 0 0 {name=x10 spiceprefix=X}
C {lab_wire.sym} -2590 -260 1 0 {name=p_vssa3_wire sig_type=std_logic lab=VSSA}
C {ipin.sym} -2780 -330 0 0 {name=p18 lab=EXT_REF_EN}
C {lab_wire.sym} -2490 -330 2 0 {name=p19 sig_type=std_logic lab=EXT_REF_ENB}
C {sg13g2_pr/sg13_hv_nmos.sym} -1650 200 2 1 {name=Mnbias1
l=500n
w=25u
ng=20
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -1650 -160 2 1 {name=Mnbias2
l=500n
w=25u
ng=20
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_hv_nmos.sym} -1380 -160 2 1 {name=Mnbias3
l=500n
w=25u
ng=20
m=1
model=sg13_hv_nmos
spiceprefix=X
}
C {lab_wire.sym} -1590 200 1 0 {name=p_vssa_ota2 sig_type=std_logic lab=VSSA}
C {lab_wire.sym} -1270 20 1 0 {name=p_vssa_ota3 sig_type=std_logic lab=VSSA}
C {iopin.sym} -1140 60 0 0 {name=p_vssa2 lab=VREG_pad}
C {DecadeDivider_2.sym} 120 -240 0 0 {name=x1}
C {DecadeDivider_2.sym} 600 -240 0 0 {name=x2}
C {DecadeDivider_2.sym} 360 -240 0 0 {name=x3}
C {DecadeDivider_2.sym} 840 -240 0 0 {name=x4}
C {DecadeDivider_2.sym} 1080 -240 0 0 {name=x5}
C {DecadeDivider_2.sym} 1320 -240 0 0 {name=x6}
C {DecadeDivider_2.sym} 1560 -240 0 0 {name=x7}
C {DecadeDividerAux.sym} -2360 -260 0 0 {name=x8}
C {lab_wire.sym} -1630 270 0 0 {name=p_vbias_lbl1 sig_type=std_logic lab=VSENSE}
C {OTA_bc.sym} -1770 -160 0 0 {name=x9}
C {sg13g2_pr/rhigh.sym} -1630 350 0 0 {name=R3
w=0.5e-6
l=31e-6
model=rhigh
body=vssa
spiceprefix=X
b=0
m=1
value="expr_eng(  ( 1.6e-4 / @w + 1360.0 * ( (@b + 1)* @l + ( 1.081*( @w - 0.04e-6 ) + 0.18e-6 )*@b ) / ( @w - 0.04e-6 ) ) / @m  )"
}
C {Cap1.sym} -1510 -440 2 1 {name=x11}
C {cap4.sym} -2180 -330 2 1 {name=x12}
C {Cap5.sym} -1820 -30 0 0 {name=x13}
